<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LwIP_HTTP_Server_Socket_RTOS.ewp</path>
  </project>
  <batchBuild />
</workspace>
