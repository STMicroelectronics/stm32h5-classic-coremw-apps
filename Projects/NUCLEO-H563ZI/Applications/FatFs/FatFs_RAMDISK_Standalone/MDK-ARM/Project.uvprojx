# Keil uVision project Project.uvprojx, settings and files
target FatFs_RAMDISK_Standalone (6210000::V6.21::ARMCLANG)
  device: STM32H563ZITx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.3.2
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x08000000-0x81FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: FatFs_RAMDISK_Standalone +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H563xx
  c include: ..\Core\Inc;../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc;../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../../../../../../Drivers/CMSIS/Include;..\FATFS\App;..\FATFS\Target;..\..\..\..\..\..\Drivers\BSP\STM32H5xx_Nucleo;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\source;..\..\..\..\..\..\Middlewares\Third_Party\FatFs\source\drivers\sram
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Application/MDK-ARM
    ./: startup_stm32h563xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32h5xx_it.c stm32h5xx_hal_msp.c
  group Application/User/FatFs/App
    ../FATFS/App/: app_fatfs.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32H5xx_Nucleo
    ../../../../../../Drivers/BSP/STM32H5xx_Nucleo/: stm32h5xx_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h5xx.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_cortex.c stm32h5xx_hal_icache.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal.c stm32h5xx_hal_exti.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/source/: diskio.c ff.c ff_gen_drv.c ffunicode.c ffsystem_baremetal.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/source/drivers/sram/: sram_diskio.c
software components: CMSIS:CORE 4.3.0
