# IAR project LwIP_TFTP_Server.ewp, settings and files
configuration LwIP_TFTP_Server (ARM, debug)
  General.OGChipSelectEditMenu: STM32H573II ST STM32H573II
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H573xx
  ICCARM.CCIncludePath2: ..\Core\Inc; ../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/BSP/Components/lan8742; ../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include; ../../../../../../Drivers/CMSIS/Include; ..\LWIP\App; ..\LWIP\Target; ..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include; ..\..\..\..\..\..\Middlewares\Third_Party\LwIP\system; ..\..\..\..\..\..\Middlewares\Third_Party\LwIP\system\arch; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\source; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\source\drivers\sd
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: TX_SINGLE_MODE_NON_SECURE=1
  OBJCOPY.OOCOutputFile: LwIP_TFTP_Server.hex
  ILINK.IlinkOutputFile: LwIP_TFTP_Server.out
  ILINK.IlinkIcfFile: stm32h573xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h573xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32h5xx_hal_msp.c stm32h5xx_it.c
  group Application/User/LWIP/App
    ../LWIP/App/: app_ethernet.c tftpserver.c tftputils.c
  group Application/User/LWIP/Target
    ../LWIP/Target/: ethernetif.c
  group Doc
    ../: README.md
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/lan8742/: lan8742.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h5xx.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_eth.c stm32h5xx_hal_eth_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_icache.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_sd.c stm32h5xx_hal_sd_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_ll_dlyb.c stm32h5xx_ll_sdmmc.c
  group Middlewares/FatFs
    ../../../../../../Middlewares/Third_Party/FatFs/source/: diskio.c ff.c ff_gen_drv.c ffsystem_template.c ffunicode.c
    ../../../../../../Middlewares/Third_Party/FatFs/source/drivers/sd/: sd_diskio.c
  group Middlewares/LwIP
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
